# Keil uVision project BatteryDrive.uvproj, settings and files
target BatteryDrive (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: BatteryDrive +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\users;..\舵机驱动;.\app;.\ads1115;.\oled;.\uCOSII\CONFIG;.\uCOSII\CORE;.\uCOSII\PORT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group src
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group users
    ./users/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group app
    ./app/: app.c bsp.c I2C.c
  group ADS1115
    ./ads1115/: ads1115.c
  group oled
    ./oled/: oled.c oledlib.c
  group uCosII-Core
    ./uCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCosII-Config
    ./uCOSII/CONFIG/: includes.h os_cfg.h
  group uCosII-Port
    ./uCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
